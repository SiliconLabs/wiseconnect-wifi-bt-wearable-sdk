# IAR project RSI_SDK_WEARABLES.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: __ICCARM__; DEBUG; CPU_MIMXRT595SFFOA_cm33; BOOT_HEADER_ENABLE=1; CR_INTEGER_PRINTF; ARM_MATH_CM33; FREEDOM; PRINTF_FLOAT_ENABLE=0; MXRT_595s; RSI_SAMPLE_HAL; RSI_WLAN_ENABLE; SDK_DEBUGCONSOLE=1; RSI_BT_ENABLE; RSI_BLE_ENABLE; RSI_ENABLE_DEMOS; RSI_SDIO_INTERFACE; RSI_PROP_PROTOCOL_ENABLE; SDK_I2C_BASED_COMPONENT_USED=1; RSI_WITH_OS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.IExtraOptions: --diag_suppress Pa093,Pe301,Pa082,Pa084,Pe177,Pe549,Pe161,Pa182,Pe186,Pe068,Pe111,Pe236,Pe120,Pe223,Pe188,Pe550,Pe167
  ICCARM.CCIncludePath2: ..\..\..\rtos; ..\..\..\CMSIS\Include; ..\..\..\devices; ..\..\..\devices\MIMXRT595S\drivers; ..\..\..\devices\MIMXRT595S; ..\..\..\devices\MIMXRT595S\utilities\str; ..\..\..\devices\MIMXRT595S\utilities\debug_console; ..\..\..\components\uart; ..\..\..\components\serial_manager; ..\..\..\components\pca9420; ..\..\..\components\lists; ..\..\..\devices\MIMXRT595S\cmsis_drivers; ..\..\..\CMSIS\Driver\Include; ..\..\..\middleware\fatfs; ..\..\..\middleware\sdmmc\inc; ..\..\..\middleware\sdmmc\port\usdhc\freertos; ..\..\..\middleware\fatfs\source\fsl_sd_disk; ..\..\..\middleware\sdmmc\port; ..\..\..\..\..\sapi\include; ..\..\..\http_client; ..\..\..\..\..\sapi\network\protocols; ..\..\..\..\..\sapi\network\protocols\http_server; ..\..\..\..\..\sapi\bluetooth; ..\..\..\board; ..\..\..\..\..\third_party\sbc_audio_codec\inc; ..\..\..\..\..\third_party\mqtt_client\src; ..\..\..\..\..\third_party\mqtt_client\src\MQTTPacket\src; ..\..\..\..\..\third_party\lwIP\src\src\include; ..\..\..\..\..\third_party\lwIP\src\src; ..\..\..\..\..\third_party\lwIP\src\src\include\lwip; ..\..\..\..\..\third_party\lwIP\src\system\arch; ..\..\..\..\..\third_party\lwIP\src\system; ..\..\..\..\..\third_party\lwIP\lwip_porting; ..\..\..\..\..\utilities\certificates; ..\..\..\..\..\examples\bt\bt_a2dp_source; ..\..\..\middleware\fatfs\source; ..\..\..\rtos\amazon-freertos\lib\FreeRTOS\portable\IAR\ARM_CM33_NTZ\non_secure; ..\..\..\rtos\amazon-freertos\lib\include\private; ..\..\..\rtos\amazon-freertos\lib\include; ..\..\..\..\..\examples\inc; ..\..\..\..\..\examples\COEX_MAX_DEMO_57; ..\..\..\..\..\examples\COEX_MAX_DEMO_57\user_input; ..\..\..\..\..\examples\COEX_MAX_DEMO_BLE_2MAS_8SLAV_69; ..\..\..\..\..\examples\COEX_MAX_DEMO_BLE_2MAS_8SLAV_69\user_input; ..\..\..\..\..\examples\UNIFIED_PROTOCOL_DEMO_54; ..\..\..\..\..\examples\COEX_THROUGHPUT_DEMO_67
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\rtos
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: rsi_sdk_wearables.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1600; __heap_size__=0x1600
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_ram.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\devices\MIMXRT595S\iar\iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 58
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT595SFFOA_cm33; ARM_MATH_CM33; DEBUG_CONSOLE_TRANSFER_NON_BLOCKING; FSL_RTOS_FREE_RTOS
  ICCARM.CCIncludePath2: ..; ../../..; ../../CMSIS/Include; ../../devices; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/xip; ../../devices/MIMXRT595S; ../../devices/MIMXRT595S/utilities/str; ../../devices/MIMXRT595S/utilities/debug_console; ../../components/uart; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/drivers; ../../components/serial_manager; ../../components/serial_manager; ../../devices/MIMXRT595S/drivers; ../../components/lists; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/drivers
  ICCARM.CCOptLevel: 1
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
  ILINK.IlinkAdditionalLibs: ../../devices/MIMXRT595S/iar/iar_lib_power.a
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 58
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT595SFFOA_cm33; BOOT_HEADER_ENABLE=1; ARM_MATH_CM33
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_ram.icf
  ILINK.IlinkAdditionalLibs: ../../devices/MIMXRT595S/iar/iar_lib_power.a
configuration flash_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 58
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT595SFFOA_cm33; BOOT_HEADER_ENABLE=1; NDEBUG; ARM_MATH_CM33
  ICCARM.CCIncludePath2: ..; ../../..; ../../CMSIS/Include; ../../devices; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/xip; ../../devices/MIMXRT595S; ../../devices/MIMXRT595S/utilities/str; ../../devices/MIMXRT595S/utilities/debug_console; ../../components/uart; ../../devices/MIMXRT595S/drivers; ../../devices/MIMXRT595S/drivers; ../../components/serial_manager; ../../components/serial_manager; ../../devices/MIMXRT595S/drivers; ../../components/lists; ../../devices/MIMXRT595S/drivers
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MIMXRT595Sxxxx_cm33_flash.icf
  ILINK.IlinkAdditionalLibs: ../../devices/MIMXRT595S/iar/iar_lib_power.a
  group examples
    ../../../../../examples/: main.c
  group examples/COEX_MAX_DEMO_57
    ../../../../../examples/COEX_MAX_DEMO_57/: lwipopts.h rsi_prop_protocol_app_DEMO_57.c rsi_ble_config_DEMO_57.h rsi_ble_device_info_DEMO_57.c rsi_ble_device_info_DEMO_57.h rsi_ble_main_task_DEMO_57.c rsi_ble_subtasks_DEMO_57.c rsi_bt_a2dp_source_avrcp_DEMO_57.c rsi_bt_spp_braktooth_vul_DEMO_57.c rsi_bt_config_DEMO_57.h rsi_common_app_DEMO_57.c rsi_common_app_DEMO_57.h rsi_lk_save_DEMO_57.c rsi_sock_test_DEMO_57.c rsi_sock_test_DEMO_57.h rsi_wlan_config_DEMO_57.h rsi_wlan_http_s_DEMO_57.c
    ../../../../../examples/COEX_MAX_DEMO_57/user_input/: rsi_user_input_DEMO_57.c rsi_user_input_DEMO_57.h
  group examples/COEX_MAX_DEMO_BLE_2MAS_8SLAV_69
    ../../../../../examples/COEX_MAX_DEMO_BLE_2MAS_8SLAV_69/: lwipopts.h rsi_prop_protocol_app_DEMO_69.c rsi_ble_config_DEMO_69.h rsi_ble_device_info_DEMO_69.c rsi_ble_device_info_DEMO_69.h rsi_ble_main_task_DEMO_69.c rsi_ble_subtasks_DEMO_69.c rsi_bt_a2dp_source_avrcp_DEMO_69.c rsi_bt_spp_braktooth_vul_DEMO_69.c rsi_bt_config_DEMO_69.h rsi_common_app_DEMO_69.c rsi_common_app_DEMO_69.h rsi_lk_save_DEMO_69.c rsi_sock_test_DEMO_69.c rsi_sock_test_DEMO_69.h rsi_wlan_config_DEMO_69.h rsi_wlan_http_s_DEMO_69.c
    ../../../../../examples/COEX_MAX_DEMO_BLE_2MAS_8SLAV_69/user_input/: rsi_user_input_DEMO_69.c rsi_user_input_DEMO_69.h
  group examples/COEX_THROUGHPUT_DEMO_67
    ../../../../../examples/COEX_THROUGHPUT_DEMO_67/: rsi_ble_config_DEMO_67.h rsi_ble_device_info.h rsi_ble_device_info_DEMO_67.c rsi_ble_main_task.c rsi_ble_subtasks.c rsi_bt_a2dp_source_avrcp.c rsi_bt_config_DEMO_67.h rsi_common_app.c rsi_common_config.h rsi_lk_save.c rsi_prop_protocol_app.c rsi_sock_test.c rsi_sock_test.h rsi_wlan_app.c rsi_wlan_config_DEMO_67.h rsi_wlan_throughput.c
  group examples/inc
    ../../../../../examples/inc/: rsi_ble_config.h rsi_bt_config.h rsi_common_app.h rsi_wlan_config.h
  group examples/UNIFIED_PROTOCOL_DEMO_54
    ../../../../../examples/UNIFIED_PROTOCOL_DEMO_54/: rsi_ble_config_DEMO_54.h rsi_ble_device_info_DEMO_54.c rsi_ble_device_info_DEMO_54.h rsi_ble_main_task_DEMO_54.c rsi_ble_master1_DEMO_54.c rsi_ble_master2_DEMO_54.c rsi_ble_sanity_task_DEMO_54.c rsi_ble_slave1_DEMO_54.c rsi_ble_slave2_DEMO_54.c rsi_ble_slave3_DEMO_54.c rsi_bt_a2dp_source_avrcp_DEMO_54.c rsi_bt_config_DEMO_54.h rsi_common_app_DEMO_54.c rsi_common_app_DEMO_54.h rsi_general_power_num_Demo_54.c rsi_lk_save_DEMO_54.c rsi_prop_protocol_app_DEMO_54.c rsi_sock_test_DEMO_54.c rsi_sock_test_DEMO_54.h rsi_wlan_config_DEMO_54.h rsi_wlan_http_s_DEMO_54.c
  group platforms/board
    ../../../board/: board.c board.h clock_config.c clock_config.h ffconf.h pin_mux.c pin_mux.h pin_mux_sdcard.c pin_mux_sdio.h RTE_Device.h
  group platforms/CMSIS
    ../../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm7.h core_dsp.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
  group platforms/CMSIS_driver
    ../../../CMSIS/Driver/Include/: Driver_Common.h Driver_SPI.h
  group platforms/component/lists
    ../../../components/lists/: generic_list.c generic_list.h
  group platforms/component/serial_manager
    ../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group platforms/component/uart
    ../../../components/uart/: uart.h usart_adapter.c
  group platforms/device
    ../../../devices/MIMXRT595S/: fsl_device_registers.h MIMXRT595S_cm33.h MIMXRT595S_cm33_features.h system_MIMXRT595S_cm33.c system_MIMXRT595S_cm33.h
  group platforms/drivers
    ../../../devices/MIMXRT595S/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dma.c fsl_dma.h fsl_flexcomm.c fsl_flexcomm.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_iap.c fsl_iap.h fsl_inputmux.c fsl_inputmux.h fsl_iopctl.h fsl_mrt.c fsl_mrt.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h fsl_usart.c fsl_usart.h fsl_usdhc.c fsl_usdhc.h
  group platforms/fatfs
    ../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
    ../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group platforms/hal
    ../../../hal/: rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_platform_init.c rsi_hal_mcu_random.c rsi_hal_mcu_sdio.c rsi_hal_mcu_spi.c rsi_hal_mcu_timer.c rsi_hal_mcu_uart.c
  group platforms/http_client
    ../../../components/pca9420/: fsl_pca9420.c fsl_pca9420.h
    ../../../http_client/: http_client.c http_client.h stringx.h urlparser.h
  group platforms/rtos
    ../../../rtos/: FreeRTOSConfig.h
  group platforms/rtos/amazon-freertos/FreeRTOS
    ../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group platforms/rtos/amazon-freertos/FreeRTOS/portable
    ../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h
  group platforms/sdmmc/inc
    ../../../middleware/sdmmc/inc/: fsl_mmc.h fsl_sd.h fsl_sdio.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group platforms/sdmmc/port
    ../../../middleware/sdmmc/port/usdhc/freertos/: fsl_sdmmc_event.c fsl_sdmmc_host.c
    ../../../middleware/sdmmc/port/: fsl_sdmmc_event.h
  group platforms/sdmmc/src
    ../../../middleware/sdmmc/src/: fsl_sd.c fsl_sdio.c fsl_sdmmc_common.c
  group platforms/startup
    ../../../devices/MIMXRT595S/iar/: startup_MIMXRT595S_cm33.s
  group platforms/utilities
    ../../../devices/MIMXRT595S/utilities/: fsl_assert.c
    ../../../devices/MIMXRT595S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../devices/MIMXRT595S/utilities/str/: fsl_str.c fsl_str.h
  group sapi/prop_protocol
    ../../../../../sapi/prop_protocol/: rsi_prop_protocol_apis.c
  group sapi/bluetooth
    ../../../../../sapi/bluetooth/: rsi_ble_gap_apis.c rsi_ble_gatt_apis.c rsi_bt_a2dp_apis.c rsi_bt_avrcp_apis.c rsi_bt_common_apis.c rsi_bt_gap_apis.c rsi_bt_sbc_codec.c rsi_bt_spp_apis.c
  group sapi/common
    ../../../../../sapi/common/: rsi_apis_non_rom.c rsi_apis_rom.c rsi_common_apis.c rsi_device_init_apis.c
  group sapi/driver
    ../../../../../sapi/driver/: rsi_prop_protocol.c rsi_bt_ble.c rsi_common.c rsi_device_init.c rsi_driver.c rsi_driver_event_handlers.c rsi_events.c rsi_events_rom.c rsi_nwk.c rsi_nwk_rom.c rsi_os_none.c rsi_pkt_mgmt.c rsi_pkt_mgmt_rom.c rsi_queue.c rsi_queue_rom.c rsi_scheduler.c rsi_scheduler_rom.c rsi_setregion_countryinfo.c rsi_timer.c rsi_utils.c rsi_utils_rom.c rsi_wlan.c
  group sapi/driver/device_interface/sdio
    ../../../../../sapi/driver/device_interface/sdio/: rsi_sdio_frame_rd_wr.c rsi_sdio_iface_init.c rsi_sdio_mem_rd_wr.c rsi_sdio_reg_rd_wr.c
  group sapi/driver/device_interface/spi
    ../../../../../sapi/driver/device_interface/spi/: rsi_spi_frame_rd_wr.c rsi_spi_functs.c rsi_spi_iface_init.c rsi_spi_mem_rd_wr.c rsi_spi_reg_rd_wr.c
  group sapi/include
    ../../../../../sapi/include/: rsi_prop_protocol.h rsi_apis_rom.h rsi_ble.h rsi_ble_apis.h rsi_ble_common_config.h rsi_bootup_config.h rsi_bt.h rsi_bt_apis.h rsi_bt_common.h rsi_bt_common_apis.h rsi_bt_common_config.h rsi_bt_sbc_codec.h rsi_bt_sdp.h rsi_common.h rsi_common_apis.h rsi_crypto.h rsi_data_types.h rsi_driver.h rsi_error.h rsi_events.h rsi_hal.h rsi_hid.h rsi_iap.h rsi_mac_api.h rsi_mac_interface.h rsi_nwk.h rsi_os.h rsi_pkt_mgmt.h rsi_puf.h rsi_qspi_defines.h rsi_queue.h rsi_scheduler.h rsi_sdio.h rsi_setregion_countryinfo.h rsi_socket.h rsi_spi_cmd.h rsi_spi_intf.h rsi_timer.h rsi_uart.h rsi_user.h rsi_utils.h rsi_wisemcu_hardware_setup.h rsi_wlan.h rsi_wlan_apis.h rsi_wlan_common_config.h rsi_wlan_defines.h rsi_wlan_non_rom.h rsi_zb_api.h rsi_zb_frames.h rsi_zb_interfaces.h rsi_zb_types.h
  group sapi/network/protocols
    ../../../../../sapi/network/protocols/: rsi_dhcp_user_class.c rsi_dhcp_user_class.h rsi_dns.c rsi_emb_mqtt_client.c rsi_emb_mqtt_client.h rsi_firmware_upgradation.c rsi_firmware_upgradation.h rsi_ftp.c rsi_http_client.c rsi_http_client.h rsi_http_ota_fw_up.c rsi_mdnsd.c rsi_mdnsd.h rsi_mqtt_client.c rsi_mqtt_client.h rsi_multicast.c rsi_multicast.h rsi_ota_fw_up.c rsi_pop3_client.c rsi_pop3_client.h rsi_raw_data.c rsi_smtp_client.c rsi_smtp_client.h rsi_sntp_client.c rsi_sntp_client.h rsi_web_socket.c rsi_web_socket.h
  group sapi/network/protocols/http_server
    ../../../../../sapi/network/protocols/http_server/: rsi_http_server.c rsi_json_handlers.c rsi_json_handlers.h
  group sapi/network/protocols/mdnsd_records
    ../../../../../sapi/network/protocols/mdnsd_records/: rsi_mdnsd_records.c rsi_mdnsd_records.h
  group sapi/network/socket
    ../../../../../sapi/network/socket/: rsi_socket.c rsi_socket_rom.c
  group sapi/rtos/freertos_wrapper
    ../../../../../sapi/rtos/freertos_wrapper/: rsi_os_wrapper.c
  group sapi/wlan
    ../../../../../sapi/wlan/: rsi_wlan_apis.c
  group third_party/lwIP/lwip_porting
    ../../../../../third_party/lwip/lwip_porting/: ethernetif.c ethernetif.h
    ../../../../../third_party/lwIP/lwip_porting/: lwip_port.c lwipopts.h sys_arch.c
  group third_party/lwIP/src/src/api
    ../../../../../third_party/lwIP/src/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group third_party/lwIP/src/src/apps/lwiperf
    ../../../../../third_party/lwIP/src/src/apps/lwiperf/: lwiperf.c
  group third_party/lwIP/src/src/apps/mdns
    ../../../../../third_party/lwIP/src/src/apps/mdns/: mdns.c
  group third_party/lwIP/src/src/apps/netbiosns
    ../../../../../third_party/lwIP/src/src/apps/netbiosns/: netbiosns.c
  group third_party/lwIP/src/src/apps/smtp
    ../../../../../third_party/lwIP/src/src/apps/smtp/: smtp.c
  group third_party/lwIP/src/src/apps/snmp
    ../../../../../third_party/lwIP/src/src/apps/snmp/: snmp_asn1.c snmp_asn1.h snmp_core.c snmp_core_priv.h snmp_mib2.c snmp_mib2_icmp.c snmp_mib2_interfaces.c snmp_mib2_ip.c snmp_mib2_snmp.c snmp_mib2_system.c snmp_mib2_tcp.c snmp_mib2_udp.c snmp_msg.c snmp_msg.h snmp_netconn.c snmp_pbuf_stream.c snmp_pbuf_stream.h snmp_priv.h snmp_raw.c snmp_scalar.c snmp_snmpv2_framework.c snmp_snmpv2_usm.c snmp_table.c snmp_threadsync.c snmp_traps.c snmpv3.c snmpv3_mbedtls.c
  group third_party/lwIP/src/src/apps/sntp
    ../../../../../third_party/lwIP/src/src/apps/sntp/: sntp.c
  group third_party/lwIP/src/src/apps/tftp
    ../../../../../third_party/lwIP/src/src/apps/tftp/: tftp_server.c
  group third_party/lwIP/src/src/core
    ../../../../../third_party/lwIP/src/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group third_party/lwIP/src/src/core/ipv4
    ../../../../../third_party/lwIP/src/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group third_party/lwIP/src/src/core/ipv6
    ../../../../../third_party/lwIP/src/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group third_party/lwIP/src/src/include/compat/posix
    ../../../../../third_party/lwIP/src/include/compat/posix/: netdb.h
  group third_party/lwIP/src/src/include/compat/posix/arpa
    ../../../../../third_party/lwIP/src/src/include/compat/posix/arpa/: inet.h
  group third_party/lwIP/src/src/include/compat/posix/net
    ../../../../../third_party/lwIP/src/src/include/compat/posix/net/: if.h
  group third_party/lwIP/src/src/include/compat/posix/sys
    ../../../../../third_party/lwIP/src/src/include/compat/posix/sys/: socket.h
  group third_party/lwIP/src/src/include/compat/stdc
    ../../../../../third_party/lwIP/src/include/compat/stdc/: errno.h
  group third_party/lwIP/src/src/include/lwip
    ../../../../../third_party/lwIP/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h init.h.cmake.in ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcp_base.h tcpip.h timeouts.h udp.h
  group third_party/lwIP/src/src/include/lwip/apps
    ../../../../../third_party/lwIP/src/src/include/lwip/apps/: altcp_proxyconnect.h altcp_tls_mbedtls_opts.h fs.h
    ../../../../../third_party/lwIP/src/include/lwip/apps/: http_client.h httpd.h httpd_opts.h lwiperf.h mdns.h mdns_opts.h mdns_priv.h mqtt.h mqtt_opts.h mqtt_priv.h netbiosns.h netbiosns_opts.h smtp.h smtp_opts.h snmp.h snmp_core.h snmp_mib2.h snmp_opts.h snmp_scalar.h snmp_snmpv2_framework.h snmp_snmpv2_usm.h snmp_table.h snmp_threadsync.h snmpv3.h sntp.h sntp_opts.h tftp_opts.h tftp_server.h
  group third_party/lwIP/src/src/include/lwip/priv
    ../../../../../third_party/lwIP/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group third_party/lwIP/src/src/include/lwip/priv
    ../../../../../third_party/lwIP/src/include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nld6.h tcp.h udp.h
  group third_party/lwIP/src/src/include/netif
    ../../../../../third_party/lwIP/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group third_party/lwIP/src/src/include/netif/ppp
    ../../../../../third_party/lwIP/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group third_party/lwIP/src/src/include/netif/ppp/polarssl
    ../../../../../third_party/lwIP/src/include/netif/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group third_party/lwIP/src/src/netif
    ../../../../../third_party/lwIP/src/src/netif/: ethernet.c
  group third_party/lwIP/src/system/arch
    ../../../../../third_party/lwIP/src/system/arch/: bpstruct.h cc.h cpu.h epstruct.h init.h lib.h perf.h sys_arch.h
  group third_party/mqtt_client/src/MQTTPacket
    ../../../../../third_party/mqtt_client/src/: MQTT_sapi_wrappers.c MQTT_wrappers.h MQTTClient.c MQTTClient.h
  group third_party/mqtt_client/src/MQTTPacket/src
    ../../../../../third_party/mqtt_client/src/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c StackTrace.h
  group third_party/sbc_audio_codec/inc
    ../../../../../third_party/sbc_audio_codec/inc/: integer.h sbc_dct.h sbc_enc_func_declare.h sbc_encoder.h sbc_if.h sbc_types.h
  group third_party/sbc_audio_codec/src
    ../../../../../third_party/sbc_audio_codec/src/: sbc_analysis.c sbc_dct.c sbc_dct_coeffs.c sbc_enc_bit_alloc_mono.c sbc_enc_bit_alloc_ste.c sbc_enc_coeffs.c sbc_encoder.c sbc_packing.c
  group utilities/certificates
    ../../../../../utilities/certificates/: ca-cert.pem cacert.pem certificate_script.py client-cert.pem client-key.pem client_certificate.crt clientcert.pem clientkey.pem GRoot_CA.pem GRootCA.pem privatekey.key server-cert.pem server-key.pem servercert.pem serverkey.pem starfieldca.pem wifi-user.pem wifiuser.pem
